# IAR project DAQV2-K66F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SDK_OS_FREE_RTOS; NDEBUG; FSL_RTOS_FREE_RTOS; CPU_MK66FN2M0VLQ18; USE_FRDM_K66F; MK66F18; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../rtos/freertos_9.0.0/License; ../devices/MK66F18/iar; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../../..; ../; ..\tcp stack\common; ..\tcp stack\cyclone_crypto; ..\tcp stack\cyclone_tcp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: DAQV2-K66F.hex
  ILINK.IlinkOutputFile: DAQV2-K66F.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  ICCARM.CCDefines: SDK_OS_FREE_RTOS; NDEBUG; FSL_RTOS_FREE_RTOS; CPU_MK66FN2M0VLQ18
  ICCARM.CCIncludePath2: ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../rtos/freertos_9.0.0/License; ../devices/MK66F18/iar; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../../..; ../
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MK66FN2M0xxx18_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h
  group drivers
    ../devices/MK66F18/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_llwu.c fsl_llwu.h fsl_lmem_cache.c fsl_lmem_cache.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sdramc.c fsl_sdramc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_tsi_v4.c fsl_tsi_v4.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_uart_freertos.c fsl_uart_freertos.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group freertos
    ../rtos/freertos_9.0.0/: ChangeLogKSDK.txt FreeRTOS_for_Kinetis_SDK_v2.0.txt
    ../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
    ../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_lptmr.c fsl_tickless_systick.c port.c portasm.s portmacro.h
    ../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../rtos/freertos_9.0.0/License/: license.txt
    ../rtos/freertos_9.0.0/Source/portable/: readme.txt
    ../rtos/freertos_9.0.0/Source/portable/Keil/: See-also-the-RVDS-directory.txt
  group sources
    ../: AgissonDriver.c AgissonDriver.h AgissonHistoryLog.c config.c config.h crypto_config.h DKD51_BDP_driver.c DKD51_BDP_driver.h DriverFunc.c DriverFunc.h EMERDriver.c EMERDriver.h flash_spi.c flash_spi.h frdm_k66f.h FreeRTOSConfig.h fsl_sdram.c fsl_sdram.h ftp_handler.c ftp_handler.h Header.h http_handler.c http_handler.h main.c modbusRTU_handler.c modbusRTU_handler.h net_config.h os_port_config.h private_mib_impl.c private_mib_impl.h private_mib_module.c private_mib_module.h res.c rs232.c rs232.h rs232task.c rs232task.h rs485.c rs485.h rs485RTU.c rs485RTU.h rs485task.c rs485task.h SDRAM.c snmp_handler.c snmp_handler.h Uart9bit.c Uart9bit.h variables.c variables.h VERTIV_M830B_driver.c VERTIV_M830B_driver.h watchdog.c watchdog.h ZTEDriver.c ZTEDriver.h ZTEHistorylog.c ZTEHistorylog.h
  group startup
    ../devices/MK66F18/iar/: startup_MK66F18.s
    ../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group tcp stack/common
    ../tcp stack/common/: compiler_port.h date_time.c date_time.h debug.c debug.h endian.c endian.h error.h fs_port.h os_port.h os_port_freertos.c os_port_freertos.h path.c path.h resource_manager.c resource_manager.h str.c str.h
  group tcp stack/cyclone_crypto
    ../tcp stack/cyclone_crypto/: aes.c aes.h asn1.c asn1.h cipher_mode_cbc.c cipher_mode_cbc.h cipher_mode_cfb.c cipher_mode_cfb.h crypto.h des.c des.h hmac.c hmac.h md5.c md5.h oid.c oid.h sha1.c sha1.h
  group tcp stack/cyclone_tcp/core
    ../tcp stack/cyclone_tcp/core/: bsd_socket.c bsd_socket.h ethernet.c ethernet.h ip.c ip.h net.c net.h net_legacy.h net_mem.c net_mem.h nic.c nic.h ping.c ping.h raw_socket.c raw_socket.h socket.c socket.h tcp.c tcp.h tcp_fsm.c tcp_fsm.h tcp_misc.c tcp_misc.h tcp_timer.c tcp_timer.h udp.c udp.h
  group tcp stack/cyclone_tcp/dhcp
    ../tcp stack/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client.h dhcp_common.c dhcp_common.h dhcp_debug.c dhcp_debug.h dhcp_server.c dhcp_server.h
  group tcp stack/cyclone_tcp/dns
    ../tcp stack/cyclone_tcp/dns/: dns_cache.c dns_cache.h dns_client.c dns_client.h dns_common.c dns_common.h dns_debug.c dns_debug.h
  group tcp stack/cyclone_tcp/drivers
    ../tcp stack/cyclone_tcp/drivers/: ksz8081.c ksz8081.h mk6x_eth.c mk6x_eth.h
  group tcp stack/cyclone_tcp/ftp
    ../tcp stack/cyclone_tcp/ftp/: ftp_client.c ftp_client.h ftp_server.c ftp_server.h ftp_server_commands.c ftp_server_commands.h ftp_server_events.c ftp_server_events.h ftp_server_misc.c ftp_server_misc.h
  group tcp stack/cyclone_tcp/http
    ../tcp stack/cyclone_tcp/http/: http_server.c http_server.h http_server_auth.c http_server_auth.h http_server_misc.c http_server_misc.h mime.c mime.h ssi.c ssi.h
  group tcp stack/cyclone_tcp/ipv4
    ../tcp stack/cyclone_tcp/ipv4/: arp.c arp.h auto_ip.c auto_ip.h icmp.c icmp.h igmp.c igmp.h ipv4.c ipv4.h ipv4_frag.c ipv4_frag.h
  group tcp stack/cyclone_tcp/ipv6
    ../tcp stack/cyclone_tcp/ipv6/: icmpv6.c icmpv6.h ipv6.c ipv6.h ipv6_frag.c ipv6_frag.h ipv6_misc.c ipv6_misc.h ipv6_pmtu.c ipv6_pmtu.h ipv6_routing.c ipv6_routing.h mld.c mld.h ndp.c ndp.h ndp_cache.c ndp_cache.h ndp_misc.c ndp_misc.h ndp_router_adv.c ndp_router_adv.h slaac.c slaac.h
  group tcp stack/cyclone_tcp/mdns
    ../tcp stack/cyclone_tcp/mdns/: mdns_client.c mdns_client.h mdns_common.c mdns_common.h mdns_responder.c mdns_responder.h
  group tcp stack/cyclone_tcp/mibs
    ../tcp stack/cyclone_tcp/mibs/: mib2_impl.c mib2_impl.h mib2_module.c mib2_module.h mib_common.c mib_common.h
  group tcp stack/cyclone_tcp/netbios
    ../tcp stack/cyclone_tcp/netbios/: nbns_client.c nbns_client.h nbns_common.c nbns_common.h nbns_responder.c nbns_responder.h
  group tcp stack/cyclone_tcp/snmp
    ../tcp stack/cyclone_tcp/snmp/: snmp_agent.c snmp_agent.h snmp_agent_dispatch.c snmp_agent_dispatch.h snmp_agent_misc.c snmp_agent_misc.h snmp_agent_pdu.c snmp_agent_pdu.h snmp_common.c snmp_common.h snmp_usm.c snmp_usm.h
  group utilities
    ../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_shell.c fsl_shell.h
