<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DAQV2-K66F.ewp</path>
    </project>
    <batchBuild />
</workspace>
