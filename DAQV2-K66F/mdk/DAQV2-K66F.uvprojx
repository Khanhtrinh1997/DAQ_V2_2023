# Keil uVision project DAQV2-K66F.uvprojx, settings and files
target DAQV2-K66F Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  output: DAQV2-K66F.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SDK_OS_FREE_RTOS, NDEBUG, FSL_RTOS_FREE_RTOS, CPU_MK66FN2M0VLQ18
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ../../; ../; ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F; ../devices/MK66F18/arm; ../rtos/freertos_9.0.0/License; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x200000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00030000
  scatter file: MK66FN2M0xxx18_flash.scf
  group sources
    ../: main.c FreeRTOSConfig.h
  group CMSIS
    ../CMSIS/Include/: cmsis_gcc.h cmsis_armcc_V6.h cmsis_armcc.h core_cmFunc.h arm_math.h core_cmSimd.h core_cm4.h arm_const_structs.h arm_common_tables.h core_cmInstr.h
    ../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h
  group board
    ../: pin_mux.h pin_mux.c clock_config.h clock_config.c board.c board.h
  group freertos
    ../rtos/freertos_9.0.0/Source/include/: projdefs.h stdint.readme deprecated_definitions.h timers.h task.h mpu_wrappers.h StackMacros.h portable.h FreeRTOS.h queue.h mpu_prototypes.h croutine.h event_groups.h list.h semphr.h
    ../rtos/freertos_9.0.0/Source/portable/Keil/: See-also-the-RVDS-directory.txt
    ../rtos/freertos_9.0.0/License/: license.txt
    ../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c heap_4.c heap_2.c heap_1.c heap_5.c
    ../rtos/freertos_9.0.0/: ChangeLogKSDK.txt FreeRTOS_for_Kinetis_SDK_v2.0.txt
    ../rtos/freertos_9.0.0/Source/: readme.txt tasks.c croutine.c list.c event_groups.c timers.c queue.c
    ../rtos/freertos_9.0.0/Source/portable/: readme.txt
    ../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: fsl_tickless_lptmr.c portmacro.h fsl_tickless_generic.h fsl_tickless_systick.c port.c
  group drivers
    ../devices/MK66F18/drivers/: fsl_lmem_cache.h fsl_pit.c fsl_mpu.h fsl_pdb.h fsl_dspi.c fsl_common.h fsl_ewm.h fsl_lptmr.h fsl_rcm.c fsl_uart.h fsl_flexbus.h fsl_adc16.c fsl_flexcan.c fsl_rnga.h fsl_sdhc.c fsl_vref.h fsl_tpm.c fsl_i2c_edma.c fsl_adc16.h fsl_lptmr.c fsl_sim.h fsl_smc.h fsl_lpuart.c fsl_enet.h fsl_lpuart_edma.c fsl_llwu.h fsl_tsi_v4.c fsl_i2c.h fsl_port.h fsl_i2c_freertos.h fsl_ftm.h fsl_vref.c fsl_sai.c fsl_dspi_freertos.c fsl_edma.c fsl_dspi_edma.c fsl_dac.h fsl_i2c_edma.h fsl_crc.c fsl_rnga.c fsl_lmem_cache.c fsl_ewm.c fsl_pit.h fsl_clock.h fsl_sai_edma.c fsl_uart_edma.h fsl_dspi.h fsl_cmt.h fsl_lpuart.h fsl_cmp.h fsl_flash.c fsl_uart_freertos.c fsl_flash.h fsl_smc.c fsl_sai_edma.h fsl_cmt.c fsl_gpio.h fsl_enet.c fsl_gpio.c fsl_crc.h fsl_sim.c fsl_sai.h fsl_tpm.h fsl_uart_edma.c fsl_dac.c fsl_sdramc.h fsl_dspi_freertos.h fsl_common.c fsl_dmamux.c fsl_rtc.h fsl_clock.c fsl_mpu.c fsl_flexcan.h fsl_dspi_edma.h fsl_flexbus.c fsl_sdramc.c fsl_sdhc.h fsl_i2c.c fsl_lpuart_freertos.h fsl_rtc.c fsl_edma.h fsl_tsi_v4.h fsl_pmc.c fsl_ftm.c fsl_pmc.h fsl_wdog.h fsl_pdb.c fsl_llwu.c fsl_lpuart_freertos.c fsl_i2c_freertos.c fsl_uart_freertos.h fsl_uart.c fsl_dmamux.h fsl_rcm.h fsl_lpuart_edma.h fsl_cmp.c fsl_wdog.c
  group startup
    ../devices/MK66F18/arm/: startup_MK66F18.s
    ../devices/MK66F18/: system_MK66F18.h system_MK66F18.c
  group utilities
    ../devices/MK66F18/utilities/: fsl_notifier.h fsl_notifier.c fsl_shell.h fsl_sbrk.c fsl_shell.c fsl_debug_console.c fsl_debug_console.h
target DAQV2-K66F Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  output: DAQV2-K66F.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: ../../; ../; ../rtos/freertos_9.0.0/Source/portable/MemMang; ../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F; ../devices/MK66F18/arm; ../rtos/freertos_9.0.0/License; ../rtos/freertos_9.0.0/Source; ../rtos/freertos_9.0.0; ../rtos/freertos_9.0.0/Source/portable; ../devices/MK66F18/drivers; ../CMSIS/Include; ../devices/MK66F18; ../rtos/freertos_9.0.0/Source/include; ../devices/MK66F18/utilities; ../rtos/freertos_9.0.0/Source/portable/Keil; ../../..; ../../..
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x200000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00030000
  scatter file: MK66FN2M0xxx18_flash.scf
